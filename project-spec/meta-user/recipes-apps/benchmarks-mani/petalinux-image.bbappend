IMAGE_INSTALL_append = " benchmarks-mani"
